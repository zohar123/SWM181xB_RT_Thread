# Keil uVision project template.uvprojx, settings and files
target SWM181 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: SWM181xB Synwit
  pack: Synwit.SWM32_DFP.1.6.8
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x1E000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output @H.bin
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c include: .\applications;.;.\drivers;.\Libraries\CMSIS\CoreSupport;.\Libraries\CMSIS\DeviceSupport;.\Libraries\SWM181_StdPeriph_Driver;.\rt-thread\include;.\rt-thread\libcpu\arm\cortex-m0;.\rt-thread\libcpu\arm\common;.\rt-thread\components\dfs\include;.\rt-thread\components\dfs\filesystems\devfs;.\rt-thread\components\dfs\filesystems\elmfat;.\rt-thread\components\drivers\include;.\rt-thread\components\drivers\spi;.\rt-thread\components\finsh;.\rt-thread\components\libc\compilers\armlibc;.\rt-thread\components\libc\compilers\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1e000
  memory RVCT9: RAM 0x20000000 size 0x4000
